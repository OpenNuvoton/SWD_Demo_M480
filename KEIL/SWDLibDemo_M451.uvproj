# Keil uVision project SWDLibDemo_M451.uvproj, settings and files
target SWDLibDemo_M451 (ARM-ADS)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: SWDLibDemo_M451
  AfterMake: fromelf --bin ".\obj\M451\@L.axf" --output ".\obj\M451\@L.bin"
  AfterMake: fromelf --text -c ".\obj\M451\@L.axf" --output ".\obj\M451\@L.txt"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c DAP.c SW_DP.c swd_host.c target_flash.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c gpio.c clk.c sys.c uart.c
    ../: SWDLib.lib
  group M451
    ../M451/: flash_blob.c target.c target_reset.c LoaderImage.s
