# Keil uVision project SWDLibDemo_NUC126.uvproj, settings and files
target SWDLibDemo_NUC126 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: M485SIDAE Nuvoton
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0-0x7FFFF) CLOCK(192000000) CPUTYPE("Cortex-M4") FPU2
  output: SWDLibDemo_NUC126
  AfterMake: fromelf --bin ".\obj\NUC126\@L.axf" --output ".\obj\NUC126\@L.bin"
  AfterMake: fromelf --text -c ".\obj\NUC126\@L.axf" --output ".\obj\NUC126\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c DAP.c SW_DP.c swd_host.c target_flash.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c gpio.c clk.c sys.c uart.c
    ../: SWDLib.lib
  group NUC126
    ../NUC126/: flash_blob.c target.c target_reset.c LoaderImage.s
