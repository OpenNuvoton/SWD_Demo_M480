# Keil uVision project SWDLibDemo_M2351NS.uvproj, settings and files
target SWDDemo_M2351NS (ARM-ADS)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: SWDLibDemo_M2351NS
  AfterMake: fromelf --bin ".\obj\M2351NS\@L.axf" --output ".\obj\M2351NS\@L.bin"
  AfterMake: fromelf --text -c ".\obj\M2351NS\@L.axf" --output ".\obj\M2351NS\@L.txt"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __TARGET_M2351_NS__
  c include: ..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
  group User
    ../: main.c swd_host.c DAP.c SW_DP.c target_flash.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c gpio.c clk.c sys.c uart.c
    ../: SWDLib.lib
  group M2351NS
    ../M2351NS/: flash_blob.c LoaderImage.s target.c target_reset.c
